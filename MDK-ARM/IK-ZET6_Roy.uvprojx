# Keil uVision project IK-ZET6_Roy.uvprojx, settings and files
target IK-ZET6_Roy (6160000::V6.16::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: IK-ZET6_Roy +hex
  AfterMake: fromelf.exe --bin -o "%L@L.bin" "#L"
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../bsp;../bsp/font;../Drivers/Components/W25Q128;../Drivers/Components/W25Q64;../Drivers/Components/AT24C02;../Drivers/Components/ATH10;../Drivers/Components/ILI9341;../Drivers/Components/MCP2515;../Drivers/Components/PCF8574T;../MODBUS;../LetterShell/port;../LetterShell/src;../easyflash/inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  library: MicroLIB
  memory RVCT1: ROM 0xc0000000 size 0x800000
  memory RVCT4: ROM 0x8008000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep shellCommand*
  group bsp
    ../bsp/: bsp.c bsp_def.h bsp_log.h bsp_msg.c bsp_debug_usart.c bsp_cpu_flash.c bsp_spi_bus.c bsp_spi_flash.c bsp_spi_can.c bsp_rtc.c bsp_timer.c bsp_I2Cx_bus.c bsp_I2C_SW.c bsp_I2C_EEPROM.c bsp_I2C_AHT.c bsp_I2C_IOexpand.c bsp_Button_FIFO.c bsp_rs485.c bsp_lcd.c bsp_can.c bsp_sdio_sd.c bsp_wifi_esp01.c
  group font
    ../bsp/font/: fonts.c exfonts.c
  group imge
    ../bsp/imge/: IK-ZET6LOGO.c
  group MODBUS
    ../MODBUS/: modbus_crc_table.c modbus_host.c
  group LetterShell
    ../LetterShell/src/: shell.c shell_cmd_list.c shell_ext.c shell_user_cmd.c
    ../LetterShell/port/: shell_port.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fsmc.c rtc.c sdio.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_sram.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_sd.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/Components
    ../Drivers/Components/W25Q128/: W25Q128.c
    ../Drivers/Components/W25Q64/: W25Q64.c
    ../Drivers/Components/AT24C02/: AT24C02.c
    ../Drivers/Components/ATH10/: AHT10.c
    ../Drivers/Components/ILI9341/: ILI9341.c
    ../Drivers/Components/MCP2515/: MCP2515.c
    ../Drivers/Components/PCF8574T/: PCF8574T.c
  group doc
    ../: .gitignore
  group EasyFlash
    ../easyflash/src/: easyflash.c ef_utils.c ef_env.c
    ../easyflash/port/: ef_port.c
    ../easyflash/inc/: ef_cfg.h
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 5.6.0
